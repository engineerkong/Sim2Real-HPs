Commit message: change config and reward for push

File: myGym/envs/robots/urdf/niryo_ned2_camera.urdf (robot description, URDF)
Before this commit: robot niryo_ned2, 11 links, 10 joints
Links:
- link camera_link: geometry collision box size=0.01 0.037 0.037; visual box size=0.01 0.037 0.037

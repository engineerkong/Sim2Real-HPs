Commit message: modify reward, collision, conf

File: myGym/envs/objects/urdf/target.urdf (robot description, URDF)
Before this commit: robot target, 1 links, 0 joints
Links:
- link baseLink: geometry visual mesh filename=../obj/target.obj scale=0.0002 0.0002 0.0002
